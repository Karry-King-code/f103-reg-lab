# Keil uVision project f103-reg-lab.uvprojx, settings and files
target f103-reg-lab (5060750)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: f103-reg-lab +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\User;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  group User
    ../User/: main.c stm32f10x_it.c
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: startup_stm32f10x_md.s system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
